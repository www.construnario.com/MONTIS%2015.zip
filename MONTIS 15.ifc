Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: C:\Users\Usuario\Desktop\JOMBAR\MONTIS 15.ifc
Time: 2016-10-25T16:40:13
Written by: ACCA_IFC.dll Version 200
Made in: Edificius 8.00c

# IfcSite, Default Site
RefLatitude: 0, 0, 0; RefLongitude: 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey (4)
In: Default Building
Name | Elevation (mm) | NominalHeight (mm)
TERRENO | -1500 | 1000
Cimentación | -500 | 500
Planta Baja | 0 | 3200
Cubierta | 3200 | 0

# IfcFurnishingElement, MONTIS 15
In: Planta Baja
Description: SEPARADOR RECUBRIM. 15 mm; Material: Color_01, <Nuevo Material...>
GENERALES II - PESO EN g POR UNIDAD: 12 g; COMPOSICIÓN: POLIPROPILENO COPOLÍMERO
GENERAL - DENSIDAD: 905 kg/m3 (ISO 1183); TEMP. MÁXIMA ALMACENAMIENTO: 60 º C; RESISTENCIA QUÍMICA: ÁCIDOS, ÁLCALIS Y DISOLVENTES; RADIACIÓN ULTRAVILOETA: BUENO; COLOR STANDARD: GRIS
TÉRMICAS - TEMPERATURA H.D.T.: 74 º C (ISO 75/B)
Pset_ManufacturerTypeInformation - ArticleNumber: 15; ModelReference: M015; ModelLabel: M015; Manufacturer: JOMBAR TERMOPLÁSTICOS; ProductionYear: 2016
PROPIEDADES MECÁNICAS - MÓDULO ELÁSTICO EN FLEXIÓN: 1100 MPa (ISO 178); RESISTENCIA AL IMPACTO CHARPI (23ºC CON ENTALLA: 12 KJ/m2 (ISO 179); IMPACTO IZOD (23º C CON MUESCA): 11 KJ/m2 (ISO 180); IMPACTO IZOD (-20º C SIN MUESCA): 60 KJ/m2 (ISO 527-1); DUREZA SHORE D: 60 ESCALA D (ISO 868); CARGA MÁXIMA POR PIEZA: 75 Kg
